Commit message: added camera code

File: jaw_gripper/resources/objects/cube.urdf (robot description, URDF)
Before this commit: robot custom, 1 links, 0 joints
Links:
- link base_link: geometry collision mesh filename=cube.obj scale=5 5 5; visual mesh filename=cube.obj scale=3 3 3
