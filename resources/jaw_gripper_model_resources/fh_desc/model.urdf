Commit message: added tray and cube

File: resources/jaw_gripper_model_resources/fh_desc/model.urdf (robot description, URDF)
Before this commit: robot smart_grasping_sandbox, 35 links, 34 joints
Joints:
- joint world_joint: origin xyz=0.0 -1.0 1.0 rpy=0.0 0.0 0.0 -> xyz=0.0 0 0 rpy=0.0 0.0 0.0
